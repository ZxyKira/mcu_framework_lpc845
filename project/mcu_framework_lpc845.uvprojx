# Keil uVision project mcu_framework_lpc845.uvprojx, settings and files
target framework-lpc845-j64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC845M301JBD64 NXP
  pack: NXP.LPC845_DFP.12.2.0
  cpu: IRAM(0x10003fe0,0x20) IRAM2(0x10000000,0x3fe0) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mcu_framework_lpc845 (library)
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: CPU_LPC845M301JBD64
  c include: ..\source;..\include;..\reference\nxp_lpc845_driver\include;..\reference\mcu_framework\include
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10003fe0 size 0x20
  memory RVCT10: RAM 0x10000000 size 0x3fe0
  group source
    ../source/: fw_chip.c fw_io.c fw_io_pin.c fw_chip_construct_io.c fw_chip_construct_spim.c fw_chip_construct_usart.c fw_spim.c fw_spim_entity.c fw_usart.c
  group include
    ../include/: fw_define.c fw_define.h fw_define_type.h fw_lpc845.h
  group debug
    ../debug/: main.c startup_LPC845.s system_LPC845.c start.c loop.c
    ../debug/inc/: system_LPC845.h
  group mcu_framework
    ../reference/mcu_framework/include/: fw_chip.h fw_io.h fw_io_entity.h fw_spim.h fw_spim_entity.h fw_usart.h
  group nxp_lpc845_driver
    ../reference/nxp_lpc845_driver/include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0plus.h fsl_acomp.h fsl_adc.h fsl_capt.h fsl_clock.h fsl_common.h fsl_crc.h fsl_ctimer.h fsl_dac.h fsl_device_registers.h fsl_dma.h fsl_gpio.h fsl_i2c.h fsl_iap.h fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_mrt.h fsl_pint.h fsl_power.h fsl_reset.h fsl_sctimer.h fsl_spi.h fsl_swm.h fsl_swm_connections.h fsl_syscon.h fsl_syscon_connections.h fsl_usart.h fsl_wkt.h fsl_wwdt.h LPC845.h LPC845_features.h
    ../reference/nxp_lpc845_driver/library/: nxp_lpc845_driver.lib
target framework-debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC845M301JBD64 NXP
  pack: NXP.LPC845_DFP.12.2.0
  cpu: as above
  output: Framework-LPC845
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: CPU_LPC845M301JBD64
  c include: ..\source;..\include;..\reference\mcu_framework\include;..\reference\nxp_lpc845_driver\include
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10003fe0 size 0x20
  memory RVCT10: RAM 0x10000000 size 0x3fe0
  scatter file: .\LPC845_flash.scf
